PRINC = "1"

RDEPENDS_${PN}-misc += "perl"
