# Inclusion of -O with -g can cause compilation failures.
#
DEBUG_OPTIMIZATION_armv7a = "-O0 -fno-omit-frame-pointer -g -feliminate-unused-debug-types -pipe"

