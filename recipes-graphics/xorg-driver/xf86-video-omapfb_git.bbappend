# LOCAL REV: WR specific fixes
#
# Limit to only builds on omap, Add COMPATIBLE_MACHINE to none so
# the BSPs can set which boards can use this recipe.
PR = "r500"

COMPATIBLE_MACHINE = "(none)"
