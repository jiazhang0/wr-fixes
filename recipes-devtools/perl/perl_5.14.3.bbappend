PRINC = "1"

RDEPENDS_perl-misc += "perl"

RDEPENDS_${PN}-pod += "perl"
